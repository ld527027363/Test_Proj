# Keil uVision project Reader433M.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: MR8100 +hex
  AfterMake: fromelf --bin !L --output upgrade.bin
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\BSP\inc;..\BSP\inc\Protocal;..\BSP\src\interface
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./: startup_stm32f4xx.s
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_adc.c
  group user
    ../BSP/src/: main.c SystemParameter.c wifi.c utility.c upgrade.c log.c buffer.c rs485.c TestMode.c battry.c
  group BSP
    ../BSP/src/: Uart.c Rtc.c stm32f4xx_it.c gpio_conf.c mcu_conf.c mcu_flash.c memory.c spi.c timer.c adc.c
  group si4463
    ../BSP/src/: radio.c radio_comm.c radio_hal.c Rf433Protocal.c si446x_api_lib.c si446x_nirq.c
  group ethernet
    ../BSP/src/: W5500.c dhcp.c utility_socket.c TcpServer.c
  group protocal
    ../BSP/src/Protocol/: base64.c Des.c procotol_apphead.c protocol_485.c protocol_application.c Protocol_Builder.c protocol_encrypt.c protocol_http.c protocol_lan.c protocol_link485.c linklayer.c
  group interface
    ../BSP/src/interface/: interface.c ble.c net.c uart1.c
  group debug
    ../BSP/src/debug/: debug.c
